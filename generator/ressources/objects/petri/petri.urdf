Commit message: UPD: urdf file for petri

File: generator/ressources/objects/petri/petri.urdf (robot description, URDF)
Before this commit: robot petri, 1 links, 0 joints
Links:
- link petri: mass 1 -> 10
